# Keil uVision project Gimbal.uvprojx, settings and files
target Gimbal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Gimbal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Components/Basic/CallBacks;../Components/Basic/structs;../Components/Basic/Tools;../Components/Basic_Control/Pid;../Components/Chassis;../Components/DJI_Motor;../Components/Gimbal;../Components/IMU/BMI/Application;../Components/IMU/BMI/Bsp;../Components/IMU/BMI/Components/Algorithm/Include;../Components/IMU/BMI/Components/Controller;../Components/IMU/BMI/Components/Devices;../Components/IMU/BMI/Lib;../Components/MCUConnect;../Components/remoteControl;../Components/shooter;../Components/IMU/BMI/Components;../Components/IMU/BMI/Components/Algorithm;..\Components\IMU\BMI\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Basic
    ../Components/Basic/CallBacks/: CallBacks.c
    ../Components/Basic/Tools/: Tools.c
  group PID
    ../Components/Basic_Control/Pid/: pid.c
  group Chassis
    ../Components/Chassis/: chassis.c
  group DJI_Motor
    ../Components/DJI_Motor/: addOns.c DJI_Motor.c
  group Gimbal
    ../Components/Gimbal/: gimbal.c
  group BMI088
    ../Components/IMU/BMI/Application/: BMI_IMU.c BMI088.c
    ../Components/IMU/BMI/Bsp/: bsp_dwt.c bsp_PWM.c
    ../Components/IMU/BMI/Components/: kalman_filter.c user_lib.c
    ../Components/IMU/BMI/Components/Algorithm/: QuaternionEKF.c
    ../Components/IMU/BMI/Components/Controller/: controller.c
    ../Components/IMU/BMI/Components/Devices/: BMI088driver.c BMI088Middleware.c transfer_function.c
    ../Components/IMU/BMI/Lib/: arm_cortexM4lf_math.lib
  group MCUConnect
    ../Components/MCUConnect/: MCUConnect.c
  group RemoteControl
    ../Components/remoteControl/: remote_control.c
  group Shooter
    ../Components/shooter/: shooter.c
software components: CMSIS:CORE 4.3.0
