# Keil uVision project Chassis.uvprojx, settings and files
target Chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Components/Basic/CallBacks;../Components/Basic/structs;../Components/Basic/Tools;../Components/Basic_Control/Pid;../Components/Basic_Control/LADRC;../Components/Chassis;../Components/DJI_Motor;../Components/MCUConnect;../Components/Referee;../Components/RemoteControl;../Components/SuperCap;../Components/UI;../Components/Vofa;../Components/IMU/BMI/Application;../Components/IMU/BMI/Bsp;../Components/IMU/BMI/Components;../Components/IMU/BMI/Components/Algorithm;../Components/IMU/BMI/Components/Algorithm/Include;../Components/IMU/BMI/Components/Controller;../Components/IMU/BMI/Components/Devices;..\Components\IMU\BMI\Lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group DJI_Motor
    ../Components/DJI_Motor/: addOns.c DJI_Motor.c
  group Basic
    ../Components/Basic/CallBacks/: CallBacks.c
    ../Components/Basic/Tools/: Tools.c
  group BasicControl
    ../Components/Basic_Control/Pid/: pid.c
  group Chassis
    ../Components/Chassis/: chassis.c
  group MCUConnect
    ../Components/MCUConnect/: MCUConnect.c
  group Referee
    ../Components/Referee/: CRC8_CRC16.c fifo.c referee.c
  group RemoteControl
    ../Components/RemoteControl/: app_et07.c bsp_wbus.c RC_task.c remote_control.c
  group UI
    ../Components/UI/: ui_g.c ui_interface.c ui_app.c
  group SuperCap
    ../Components/SuperCap/: SuperCap.c
  group vofa
    ../Components/Vofa/: Vofa.c
  group BMI088
    ../Components/IMU/BMI/Application/: BMI_IMU.c BMI088.c
    ../Components/IMU/BMI/Bsp/: bsp_dwt.c bsp_PWM.c
    ../Components/IMU/BMI/Components/Algorithm/: QuaternionEKF.c
    ../Components/IMU/BMI/Components/: kalman_filter.c user_lib.c
    ../Components/IMU/BMI/Components/Controller/: controller.c
    ../Components/IMU/BMI/Components/Devices/: BMI088driver.c BMI088Middleware.c transfer_function.c
    ../Components/IMU/BMI/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
